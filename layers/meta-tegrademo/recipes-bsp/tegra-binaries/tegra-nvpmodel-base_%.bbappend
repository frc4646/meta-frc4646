NVPMODEL_CONFIG_DEFAULT ??= "2"
