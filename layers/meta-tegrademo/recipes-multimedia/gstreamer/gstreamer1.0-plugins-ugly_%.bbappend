# x264enc, which encodes image_streamer's WebRTC video.  Its license flag is
# accepted in tegrademo.inc.
PACKAGECONFIG:append = " x264"
