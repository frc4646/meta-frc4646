# The nicesrc and nicesink elements, which webrtcbin uses for ICE.
PACKAGECONFIG:append = " gstreamer"
