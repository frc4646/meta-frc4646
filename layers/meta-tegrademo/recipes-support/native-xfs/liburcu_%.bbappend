# Needed on the build host to create the xfs root filesystem image.
BBCLASSEXTEND += "native"
