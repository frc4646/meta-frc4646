DESCRIPTION = "Packagegroup for inclusion in all Tegra demo images"

LICENSE = "MIT"

PACKAGE_ARCH = "${TUNE_PKGARCH}"

inherit packagegroup

RDEPENDS:${PN} = " \
    procps \
    sshfs-fuse \
    strace \
    tegra-tools-tegrastats \
    tegra-libraries-camera \
    tegra-libraries-core \
    tegra-libraries-multimedia \
    tegra-libraries-eglcore \
    eglexternalplatform \
    l4t-nvidia-glheaders \
    tegra-mmapi-dev \
    libatomic \
    libffi \
    xserver-xorg \
    xauth \
    opencv \
    opencv-dev \
    libvdpau \
    libva \
    man-db \
    man \
    libegl \
    libcap \
    libcap-bin \
    tensorrt-core \
    tensorrt-core-dev \
    tensorrt-plugins-prebuilt \
    tensorrt-trtexec \
    mesa \
    mesa-dev \
    libopencv-core-dev \
    libopencv-imgproc-dev \
    libopencv-highgui-dev \
    libopencv-videoio-dev \
    libopencv-imgcodecs-dev \
    gstreamer1.0-plugins-tegra-dev \
    gstreamer1.0-plugins-good-dev \
    gstreamer1.0-plugins-base-dev \
    gstreamer1.0-plugins-nvdrmvideosink-dev \
    gstreamer1.0-plugins-nveglgles-dev \
    gstreamer1.0-plugins-nvjpeg-dev \
    gstreamer1.0-plugins-nvv4l2camerasrc-dev \
    gstreamer1.0-plugins-nvvidconv-dev \
    gstreamer1.0-plugins-nvvideo4linux2-dev \
    gstreamer1.0-rtsp-server-dev \
    gstreamer1.0-plugins-nveglgles \
    rsync \
    vim \
    media-ctl \
    gstreamer1.0-plugins-bad-dev \
    gstreamer1.0-plugins-bad-webrtc \
    gstreamer1.0-plugins-bad-srtp \
    gstreamer1.0-plugins-bad-sctp \
    gstreamer1.0-plugins-bad-dtls \
    gstreamer1.0-plugins-ugly-x264 \
    libnice \
    alsa-lib-dev \
    can-utils \
    bash-completion \
    linux-firmware-rtl8168 \
    e2fsprogs-tune2fs \
    e2fsprogs-resize2fs \
    v4l-utils \
    trace-cmd \
    sysstat \
    gdb \
    cuda-cudart-dev \
    cuda-target-environment \
    cuda-nvcc \
    cuda-nvcc-headers \
    tegra-tools-jetson-clocks \
    sudo \
    sed \
    python3 \
    git \
    cpufrequtils \
    openssh \
    libnice-dev \
    feh \
    usbutils \
    clinfo \
    jq \
    net-tools \
    ethtool \
    parted \
    file \
    smartmontools \
    nvme-cli \
    psmisc \
    chrony \
    lmsensors \
    xfsprogs \
    bridge-utils \
    glibc \
    glibc-utils \
    ldd \
    localedef \
    libxkbfile \
    autossh \
    gtk+3 \
    libglvnd \
    libglvnd-dev \
    glib-2.0-dev \
    libxcb-dev \
    libxcb-glx \
    zlib \
    wayland \
    egl-wayland \
    egl-wayland-dev \
    wayland-protocols \
    wayland-dev \
    systemd \
    wget \
    gnupg \
    gcc \
    libstdc++ \
    libgcc \
    cuda-toolkit \
    users-pi \
    aos-configuration \
    chronyc \
    kernel-module-uvcvideo \
    kernel-module-usbmon \
    kernel-module-sctp \
    kernel-module-nfnetlink \
    kernel-module-sch-prio \
    kernel-module-sch-fq-codel \
    kernel-module-sch-codel \
    kernel-module-sch-htb \
    kernel-module-sch-tbf \
    kernel-module-sch-sfq \
    kernel-module-sch-multiq \
    kernel-module-sch-mqprio \
    kernel-module-sch-taprio \
    kernel-module-sch-etf \
    kernel-module-sch-cbs \
    kernel-module-sch-netem \
    kernel-module-sch-ingress \
    kernel-module-cls-flower \
    kernel-module-act-skbedit \
    kernel-module-act-mirred \
    kernel-module-act-police \
    kernel-module-act-gact \
    tshark \
    tegra-bootfiles-dev \
    perf \
    bpftrace \
    kexec \
    rt-tests \
    stress-ng \
    iproute2-tc \
    fio \
    iperf3 \
    linuxptp \
 "
# clang
#    gcc
#    g++
